<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10100\blank\iar\nrf_crypto_aes_ccm_pca10100.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\nrf_crypto_aes_ccm_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\nrf_crypto_aes_ccm_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100e\blank\iar\nrf_crypto_aes_ccm_pca10100e.ewp</path>
  </project>  <batchBuild/>
</workspace>