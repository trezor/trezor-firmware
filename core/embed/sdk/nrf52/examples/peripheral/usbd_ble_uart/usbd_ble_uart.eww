<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\usbd_ble_uart_pca10056_s140.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100\s113\iar\usbd_ble_uart_pca10100_s113.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100e\s140\iar\usbd_ble_uart_pca10100e_s140.ewp</path>
  </project>  <batchBuild/>
</workspace>