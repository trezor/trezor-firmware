<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10100\blank\iar\usbd_pca10100.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\usbd_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100e\blank\iar\usbd_pca10100e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\test\pca10100_fpga\blank\iar\usbd_pca10100_fpga.ewp</path>
  </project>  <batchBuild/>
</workspace>