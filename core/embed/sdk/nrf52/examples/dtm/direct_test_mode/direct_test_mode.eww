<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10100\blank\iar\direct_test_mode_pca10100.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10112\blank\iar\direct_test_mode_pca10112.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\direct_test_mode_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\direct_test_mode_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100e\blank\iar\direct_test_mode_pca10100e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\blank\iar\direct_test_mode_pca10056e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\blank\iar\direct_test_mode_pca10040e.ewp</path>
  </project>  <batchBuild/>
</workspace>