<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\d52\s212\iar\ant_fs_client_d52_s212.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s212\iar\ant_fs_client_pca10040_s212.ewp</path>
  </project>  <batchBuild/>
</workspace>